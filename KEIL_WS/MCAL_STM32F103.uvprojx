# Keil uVision project MCAL_STM32F103.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MCAL_STM32F103
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\_src
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group adc
    ../_src/adc/: adc.c interface_adc.h private_adc.h
  group eeprom
    ../_src/eeprom/: eeprom.c interface_eeprom.h private_eeprom.h
  group gpio
    ../_src/gpio/: gpio.c interface_gpio.h private_gpio.h
  group gpt
    ../_src/gpt/: gpt.c interface_gpt.h private_gpt.h
  group i2c
    ../_src/i2c/: i2c.c interface_i2c.h private_i2c.h
  group nvic
    ../_src/nvic/: interface_nvic.h nvic.c private_nvic.h
  group rcc
    ../_src/rcc/: interface_rcc.h private_rcc.h rcc.c
  group spi
    ../_src/spi/: interface_spi.h private_spi.h spi.c
  group systick
    ../_src/systick/: interface_systick.h private_systick.h systick.c
  group usart
    ../_src/usart/: interface_usart.h private_usart.h usart.c
  group unit_test
    ../_src/_unit_test/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
